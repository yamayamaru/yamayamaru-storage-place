#include    <stdio.h>
#include    <io.h>
#include    <fcntl.h>
#include    <string.h>
#include    <dos.h>
#include    <i86.h>
#include    <conio.h>
#include    <math.h>

#define SCREEN_WIDTH        (640)
#define SCREEN_HEIGHT       (400)

void gstart(void);
void color16(void);
void pset(int x, int y, int color);
void fill_blue(char a);
void fill_red(char a);
void fill_green(char a);
void fill_int(char a);
void clear_text(void);
void put_vram_char(int x, int y, int ch, int attri);
void pc9821_on(void);
void pc9821_off(void);
int map_physical_momory_at_end_of_segment(unsigned int segment_sel, unsigned int base_addr, int number_of_pages, unsigned int *segment_off);
int allocate_segment(unsigned int allocate_pages, unsigned int *segment_sel);
int free_segment(unsigned int segment_sel);
void pset256(int x, int y, int color);
void set_palette(int color_no, int red, int green, int blue);

int second();
long millis01();
void delay01(int a);

extern  unsigned char far *vram01;

extern const unsigned char palette256_web216[];
extern const unsigned char palette256_default24[];

double d[161];
int col2r[161];
int col2g[161];
int col2b[161];

void hat05(void);

int main(int argc, char *argv[]) {
    int i, j;
    unsigned int p_vram_addr = 0x00F00000;
    unsigned int p_vram_seg;
    unsigned int p_vram_off;
    unsigned int p_vram_page_size = 512 * 1024 / 4096;

    gstart();
    color16();

    pc9821_on();

    // size 0のセグメントディスクリプタを取得
    if (allocate_segment(0, &p_vram_seg) != 0) {
        fprintf(stderr, "allocate_segment failure\n");
        return 0;
    }

    // セグメントにVRAMをマッピング
    if (map_physical_momory_at_end_of_segment(p_vram_seg, p_vram_addr, p_vram_page_size, &p_vram_off) != 0) {
        fprintf(stderr, "map_physical_momory_at_end_of_segment failure\n");
        free_segment(p_vram_seg);
        return 0;
    }

    vram01 = (unsigned char far *)MK_FP(p_vram_seg, p_vram_off);

    clear_text();

    for (i = 0; i <= 160; i++) {
        col2r[i] = 0;
        col2g[i] = 0;
        col2b[i] = 0;
        if (i <= 31) {
            col2b[i] = i;
        }
        if ((i > 32) && (i <= 63)) {
            col2b[i] = (63 - i);
            col2r[i] = (i -33);
        }
        if (i == 64) {
            col2r[i] = (i - 33);
        }
        if ((i > 64) && (i <= 95)) {
            col2r[i] = (95 - i);
            col2g[i] = (i - 65);
        }
        if (i == 96) {
            col2g[i] = (i - 65);
        }
        if ((i > 96) && (i <= 127)) {
            col2g[i] = ((127 - i) + (i - 97));
            col2b[i] = (i - 97);
        }
        if (i == 128) {
            col2g[i] = (i - 97);
            col2b[i] = (i - 97);
        }
        if ((i > 128) && (i <= 159)) {
            col2g[i] = ((159 - i) + (i - 129));
            col2b[i] = ((159 - i) + (i - 129));
            col2r[i] = (i - 129);
        }
        if (i >= 160) {
            col2g[i] = 31;
            col2b[i] = 31;
            col2r[i] = 31;
        }
    }

    for (i = 0; i <= 160; i++) {
        set_palette(i, col2r[i] * 8, col2g[i] * 8, col2b[i] * 8);
    }

    /* clear vram */
    for (j = 0; j < 400; j++) {
        for (i = 0; i < 640; i++) {
            pset256(i, j, 0);
        }
    }



    hat05();



    while(!kbhit());

    for (i = 0; i < 256; i++) {
        //set_palette(i, palette256_web216[i * 4 + 2], palette256_web216[i * 4 + 1], palette256_web216[i * 4 + 0]);
        set_palette(i, palette256_default24[i * 4 + 2], palette256_default24[i * 4 + 1], palette256_default24[i * 4 + 0]);
    }

    for (j = 0; j < 400; j++) {
        for (i = 0; i < 640; i++) {
            pset256(i, j, 0);
        }
    }

    pc9821_off();

    // VRAMセグメントを開放
    if (free_segment(p_vram_seg) != 0) {
        fprintf(stderr, "free_segment failure\n");
        return 0;
    }

    return 0;
}


void hat05(void) {
    int       i, x1, y1, zz, px, py, sxi;
    double    dr, r, z, sx, sy, x, y;
    int       xmax, ymax;

    xmax = SCREEN_WIDTH;
    ymax = SCREEN_HEIGHT;

    for (i = 0; i < 160; ++i) {
        d[i] = 100.0;
    }

    dr = 3.141592653589793 / 180.0;
    for (y1 = -1800; y1 <= 1800; y1 += 10) {
        y = y1 / 10.0;
        for (x1 = -1800; x1 < 1800; x1 += 2) {
            x = x1 / 10.0;
            r = dr * sqrt((double)x * (double)x + (double)y * (double)y);
            z = 100 * cos(r) - 30 * cos(3*r);
            sx = 80 + x / 3 - y / 6;
            sy = 40 - y / 6 - z / 4;
            sxi = (int)sx;
            if ((sxi < 0) || (sxi > 160)) continue;
            if (d[sxi] <= sy) continue;

            zz = (int)((z + 100) * 0.035 / 6 * 159) + 1;

            if (zz > 160) zz = 160;
            px = (int)(sx * 2.0 * xmax / 320.0);
            py = (int)(sy * 2.0 * ymax / 200.0);
            pset256(px, py, zz);

            d[sxi] = sy;
        }
    }
}


int second() {
    struct dostime_t time01;
    _dos_gettime(&time01);

    return (double)(((time01.hour * 3600L + time01.minute * 60L + time01.second) * 1000 + time01.hsecond * 10) / 1000.0);
}

long millis01() {
    return (long)second() * 1000;
}

void delay01(int a) {
    double time0001, time0002;
    if (a <= 0) return;
    time0001 = millis01();
    time0002 = (double)a;
    while ((millis01() - time0001) < time0002);
}


#define PC98_XLINE_WIDTH    640
/*
#define VRAM_BLUE  0xa8000UL
#define VRAM_RED   0xb0000UL
#define VRAM_GREEN 0xb8000UL
#define VRAM_INT   0xe0000UL
#define TEXT_VRAM  0xa0000UL
#define TEXT_VRAM_ATTRI  0xa2000UL
*/


#define TEXT_VRAM  0x00000UL
#define TEXT_VRAM_ATTRI  0x02000UL

#define VRAM_BLUE      0x00000000
#define VRAM_RED       0x00008000
#define VRAM_GREEN     0x00010000
#define VRAM_INT       0x00038000

unsigned char far *vram01;
unsigned char far *cvram01;

void gstart(void) {     /* グラフィック表示ON */
    union REGS regs;
    regs.h.ah = 0x40;
    int386(0x18, &regs, &regs);


    vram01 = (unsigned char far *)MK_FP(0x0044, 0x00000000);

    cvram01 = (unsigned char far *)MK_FP(0x001c, 0x00000000);
}

void color16(void) {    /* 16色表示にする */
    outp(0x6a, 1);
    outp(0xa2, 0x4b);
    outp(0xa0, 0);
    outp(0x68, 8);
}

void clear_text(void) {
    int i, j;
    for (j = 0; j < 40; j++) {
        for (i = 0; i < 80; i++) {
            put_vram_char(i, j, 0x20, 0xe1);
        }
    }
}

/*
  アトリビュート
    bit0: 表示  1:表示 0:非表示
    bit1: 点滅  1:点滅 0:通常
    bit2: 反転  1:反転 0:通常
    bit3: アンダーライン     1:アンダーライン 0:通常
    bit4: バーティカルライン 1:縦線           0:通常
    bit5: 青
    bit6: 赤
    bit7; 緑
*/
void put_vram_char(int x, int y, int ch, int attri) {
    unsigned int p01;
    unsigned int d;
    d = 2 * (x + y * 80);
    p01 = TEXT_VRAM;
    *(cvram01 + p01 + d) = (char)ch;            // 半角キャラクタのみ;
    *(cvram01 + p01 + d + 1) = 0;
    p01 = TEXT_VRAM_ATTRI;
    *(cvram01 + p01 + d) = (char)attri;
    *(cvram01 + p01 + d + 1) = (char)0;
}

void fill_blue(char a) {
    unsigned int  p01;
    unsigned int  i;

    p01 = VRAM_BLUE;
    for (i = 0; i < 0x8000; i++) {
        *(vram01 + p01++) = a;
    }
}

void fill_red(char a) {
    unsigned int  p01;
    unsigned int  i;

    p01 = VRAM_RED;
    for (i = 0; i < 0x8000; i++) {
        *(vram01 + p01++) = a;
    }
}

void fill_green(char a) {
    unsigned int  p01;
    unsigned int  i;

    p01 = VRAM_GREEN;
    for (i = 0; i < 0x8000; i++) {
        *(vram01 + p01++) = a;
    }
}

void fill_int(char a) {
    unsigned int  p01;
    unsigned int  i;

    p01 = VRAM_INT;
    for (i = 0; i < 0x8000; i++) {
        *(vram01 + p01++) = a;
    }
}

void pset(int x, int y, int color) {
    unsigned int addr01;
    unsigned int bit01;
    unsigned int p;
    unsigned char c;

    addr01 = (unsigned int)(((unsigned long)PC98_XLINE_WIDTH * y + x) >> 3);
    bit01 = x & 0x07;
    c = 0x80 >> bit01;

    p = VRAM_BLUE;
    p += addr01;
    if (color & 0x01) {
        *(vram01 + p) = *(vram01 + p) | c;
    } else {
        *(vram01 + p) = *(vram01 + p) & ~c;
    }
    p = VRAM_GREEN;
    p += addr01;
    if (color & 0x04) {
        *(vram01 + p) = *(vram01 + p) | c;
    } else {
        *(vram01 + p) = *(vram01 + p) & ~c;
    }
    p = VRAM_RED;
    p += addr01;
    if (color & 0x02) {
        *(vram01 + p) = *(vram01 + p) | c;
    } else {
        *(vram01 + p) = *(vram01 + p) & ~c;
    }
    p = VRAM_INT;
    p += addr01;
    if (color & 0x08) {
        *(vram01 + p) = *(vram01 + p) | c;
    } else {
        *(vram01 + p) = *(vram01 + p) & ~c;
    }
}

void pc9821_on(void)
{
    unsigned char far *proto_addr01;

/*
#if _HSYNC_
    // HSYNC -> 31.47 KHz 
    if( (inp(0x09a8) & 0x01) == 0){
        outp(0x09a8,0x01);
        Hmode = 1;
    }
#endif
*/

    // 256 color mode
    outp(0x6a,0x07);
    outp(0x6a,0x21);
    outp(0x6a,0x06);

    // Packed Pixel
    // *((char *)0xe0100) = 0x00;
    proto_addr01 = (unsigned char far *)MK_FP(0x34, 0xe0100);
    *proto_addr01 = 0x00;

    // 16[MB] System Area -> VRAM ON
    // *((char *)0xe0102) = 0x01;
    proto_addr01 = (unsigned char far *)MK_FP(0x34, 0xe0102);
    *proto_addr01 = 0x01;

    // Graphics Start
    outp(0xa2,0x0d);
}

void pc9821_off(void)
{
    unsigned char far *proto_addr01;

    // 16[MB] System Area -> VRAM OFF
    // *((char *)0xe0102) = 0x00;
    proto_addr01 = (unsigned char far *)MK_FP(0x34, 0xe0102);
    *proto_addr01 = 0x00;

    // 16 Color (standard) mode
    outp(0x6a,0x07);
    outp(0x6a,0x20);
    outp(0x6a,0x06);

/*
#if _HSYNC_
    // HSYNC -> 24.8? KHz
    if(Hmode==1)
        outp(0x09a8,0x00);
#endif
*/

    /* TEXT Start */
    outp(0x62,0x0d);

}

void pset256(int x, int y, int color) {
    if ((x > 640) || (x < 0)) return;
    if ((y > 400) || (y < 0)) return;

    vram01[y * PC98_XLINE_WIDTH + x] = (unsigned char)color;
}

void set_palette(int color_no, int red, int green, int blue) {
    outp(0xa8, color_no & 0xff);
    outp(0xaa, green & 0xff);
    outp(0xac, red & 0xff);
    outp(0xae, blue & 0xff);
}

const unsigned char palette256_default24[] = {
    0x00,0x00,0x00,0x00,0x00,0x00,0x80,0x00,0x00,0x80,0x00,0x00,0x00,0x80,0x80,0x00,0x80,0x00,0x00,0x00,
    0x80,0x00,0x80,0x00,0x80,0x80,0x00,0x00,0xc0,0xc0,0xc0,0x00,0xc0,0xdc,0xc0,0x00,0xf0,0xca,0xa6,0x00,
    0xaa,0x3f,0x2a,0x00,0xff,0x3f,0x2a,0x00,0x00,0x5f,0x2a,0x00,0x55,0x5f,0x2a,0x00,0xaa,0x5f,0x2a,0x00,
    0xff,0x5f,0x2a,0x00,0x00,0x7f,0x2a,0x00,0x55,0x7f,0x2a,0x00,0xaa,0x7f,0x2a,0x00,0xff,0x7f,0x2a,0x00,
    0x00,0x9f,0x2a,0x00,0x55,0x9f,0x2a,0x00,0xaa,0x9f,0x2a,0x00,0xff,0x9f,0x2a,0x00,0x00,0xbf,0x2a,0x00,
    0x55,0xbf,0x2a,0x00,0xaa,0xbf,0x2a,0x00,0xff,0xbf,0x2a,0x00,0x00,0xdf,0x2a,0x00,0x55,0xdf,0x2a,0x00,
    0xaa,0xdf,0x2a,0x00,0xff,0xdf,0x2a,0x00,0x00,0xff,0x2a,0x00,0x55,0xff,0x2a,0x00,0xaa,0xff,0x2a,0x00,
    0xff,0xff,0x2a,0x00,0x00,0x00,0x55,0x00,0x55,0x00,0x55,0x00,0xaa,0x00,0x55,0x00,0xff,0x00,0x55,0x00,
    0x00,0x1f,0x55,0x00,0x55,0x1f,0x55,0x00,0xaa,0x1f,0x55,0x00,0xff,0x1f,0x55,0x00,0x00,0x3f,0x55,0x00,
    0x55,0x3f,0x55,0x00,0xaa,0x3f,0x55,0x00,0xff,0x3f,0x55,0x00,0x00,0x5f,0x55,0x00,0x55,0x5f,0x55,0x00,
    0xaa,0x5f,0x55,0x00,0xff,0x5f,0x55,0x00,0x00,0x7f,0x55,0x00,0x55,0x7f,0x55,0x00,0xaa,0x7f,0x55,0x00,
    0xff,0x7f,0x55,0x00,0x00,0x9f,0x55,0x00,0x55,0x9f,0x55,0x00,0xaa,0x9f,0x55,0x00,0xff,0x9f,0x55,0x00,
    0x00,0xbf,0x55,0x00,0x55,0xbf,0x55,0x00,0xaa,0xbf,0x55,0x00,0xff,0xbf,0x55,0x00,0x00,0xdf,0x55,0x00,
    0x55,0xdf,0x55,0x00,0xaa,0xdf,0x55,0x00,0xff,0xdf,0x55,0x00,0x00,0xff,0x55,0x00,0x55,0xff,0x55,0x00,
    0xaa,0xff,0x55,0x00,0xff,0xff,0x55,0x00,0x00,0x00,0x7f,0x00,0x55,0x00,0x7f,0x00,0xaa,0x00,0x7f,0x00,
    0xff,0x00,0x7f,0x00,0x00,0x1f,0x7f,0x00,0x55,0x1f,0x7f,0x00,0xaa,0x1f,0x7f,0x00,0xff,0x1f,0x7f,0x00,
    0x00,0x3f,0x7f,0x00,0x55,0x3f,0x7f,0x00,0xaa,0x3f,0x7f,0x00,0xff,0x3f,0x7f,0x00,0x00,0x5f,0x7f,0x00,
    0x55,0x5f,0x7f,0x00,0xaa,0x5f,0x7f,0x00,0xff,0x5f,0x7f,0x00,0x00,0x7f,0x7f,0x00,0x55,0x7f,0x7f,0x00,
    0xaa,0x7f,0x7f,0x00,0xff,0x7f,0x7f,0x00,0x00,0x9f,0x7f,0x00,0x55,0x9f,0x7f,0x00,0xaa,0x9f,0x7f,0x00,
    0xff,0x9f,0x7f,0x00,0x00,0xbf,0x7f,0x00,0x55,0xbf,0x7f,0x00,0xaa,0xbf,0x7f,0x00,0xff,0xbf,0x7f,0x00,
    0x00,0xdf,0x7f,0x00,0x55,0xdf,0x7f,0x00,0xaa,0xdf,0x7f,0x00,0xff,0xdf,0x7f,0x00,0x00,0xff,0x7f,0x00,
    0x55,0xff,0x7f,0x00,0xaa,0xff,0x7f,0x00,0xff,0xff,0x7f,0x00,0x00,0x00,0xaa,0x00,0x55,0x00,0xaa,0x00,
    0xaa,0x00,0xaa,0x00,0xff,0x00,0xaa,0x00,0x00,0x1f,0xaa,0x00,0x55,0x1f,0xaa,0x00,0xaa,0x1f,0xaa,0x00,
    0xff,0x1f,0xaa,0x00,0x00,0x3f,0xaa,0x00,0x55,0x3f,0xaa,0x00,0xaa,0x3f,0xaa,0x00,0xff,0x3f,0xaa,0x00,
    0x00,0x5f,0xaa,0x00,0x55,0x5f,0xaa,0x00,0xaa,0x5f,0xaa,0x00,0xff,0x5f,0xaa,0x00,0x00,0x7f,0xaa,0x00,
    0x55,0x7f,0xaa,0x00,0xaa,0x7f,0xaa,0x00,0xff,0x7f,0xaa,0x00,0x00,0x9f,0xaa,0x00,0x55,0x9f,0xaa,0x00,
    0xaa,0x9f,0xaa,0x00,0xff,0x9f,0xaa,0x00,0x00,0xbf,0xaa,0x00,0x55,0xbf,0xaa,0x00,0xaa,0xbf,0xaa,0x00,
    0xff,0xbf,0xaa,0x00,0x00,0xdf,0xaa,0x00,0x55,0xdf,0xaa,0x00,0xaa,0xdf,0xaa,0x00,0xff,0xdf,0xaa,0x00,
    0x00,0xff,0xaa,0x00,0x55,0xff,0xaa,0x00,0xaa,0xff,0xaa,0x00,0xff,0xff,0xaa,0x00,0x00,0x00,0xd4,0x00,
    0x55,0x00,0xd4,0x00,0xaa,0x00,0xd4,0x00,0xff,0x00,0xd4,0x00,0x00,0x1f,0xd4,0x00,0x55,0x1f,0xd4,0x00,
    0xaa,0x1f,0xd4,0x00,0xff,0x1f,0xd4,0x00,0x00,0x3f,0xd4,0x00,0x55,0x3f,0xd4,0x00,0xaa,0x3f,0xd4,0x00,
    0xff,0x3f,0xd4,0x00,0x00,0x5f,0xd4,0x00,0x55,0x5f,0xd4,0x00,0xaa,0x5f,0xd4,0x00,0xff,0x5f,0xd4,0x00,
    0x00,0x7f,0xd4,0x00,0x55,0x7f,0xd4,0x00,0xaa,0x7f,0xd4,0x00,0xff,0x7f,0xd4,0x00,0x00,0x9f,0xd4,0x00,
    0x55,0x9f,0xd4,0x00,0xaa,0x9f,0xd4,0x00,0xff,0x9f,0xd4,0x00,0x00,0xbf,0xd4,0x00,0x55,0xbf,0xd4,0x00,
    0xaa,0xbf,0xd4,0x00,0xff,0xbf,0xd4,0x00,0x00,0xdf,0xd4,0x00,0x55,0xdf,0xd4,0x00,0xaa,0xdf,0xd4,0x00,
    0xff,0xdf,0xd4,0x00,0x00,0xff,0xd4,0x00,0x55,0xff,0xd4,0x00,0xaa,0xff,0xd4,0x00,0xff,0xff,0xd4,0x00,
    0x55,0x00,0xff,0x00,0xaa,0x00,0xff,0x00,0x00,0x1f,0xff,0x00,0x55,0x1f,0xff,0x00,0xaa,0x1f,0xff,0x00,
    0xff,0x1f,0xff,0x00,0x00,0x3f,0xff,0x00,0x55,0x3f,0xff,0x00,0xaa,0x3f,0xff,0x00,0xff,0x3f,0xff,0x00,
    0x00,0x5f,0xff,0x00,0x55,0x5f,0xff,0x00,0xaa,0x5f,0xff,0x00,0xff,0x5f,0xff,0x00,0x00,0x7f,0xff,0x00,
    0x55,0x7f,0xff,0x00,0xaa,0x7f,0xff,0x00,0xff,0x7f,0xff,0x00,0x00,0x9f,0xff,0x00,0x55,0x9f,0xff,0x00,
    0xaa,0x9f,0xff,0x00,0xff,0x9f,0xff,0x00,0x00,0xbf,0xff,0x00,0x55,0xbf,0xff,0x00,0xaa,0xbf,0xff,0x00,
    0xff,0xbf,0xff,0x00,0x00,0xdf,0xff,0x00,0x55,0xdf,0xff,0x00,0xaa,0xdf,0xff,0x00,0xff,0xdf,0xff,0x00,
    0x55,0xff,0xff,0x00,0xaa,0xff,0xff,0x00,0xff,0xcc,0xcc,0x00,0xff,0xcc,0xff,0x00,0xff,0xff,0x33,0x00,
    0xff,0xff,0x66,0x00,0xff,0xff,0x99,0x00,0xff,0xff,0xcc,0x00,0x00,0x7f,0x00,0x00,0x55,0x7f,0x00,0x00,
    0xaa,0x7f,0x00,0x00,0xff,0x7f,0x00,0x00,0x00,0x9f,0x00,0x00,0x55,0x9f,0x00,0x00,0xaa,0x9f,0x00,0x00,
    0xff,0x9f,0x00,0x00,0x00,0xbf,0x00,0x00,0x55,0xbf,0x00,0x00,0xaa,0xbf,0x00,0x00,0xff,0xbf,0x00,0x00,
    0x00,0xdf,0x00,0x00,0x55,0xdf,0x00,0x00,0xaa,0xdf,0x00,0x00,0xff,0xdf,0x00,0x00,0x55,0xff,0x00,0x00,
    0xaa,0xff,0x00,0x00,0x00,0x00,0x2a,0x00,0x55,0x00,0x2a,0x00,0xaa,0x00,0x2a,0x00,0xff,0x00,0x2a,0x00,
    0x00,0x1f,0x2a,0x00,0x55,0x1f,0x2a,0x00,0xaa,0x1f,0x2a,0x00,0xff,0x1f,0x2a,0x00,0x00,0x3f,0x2a,0x00,
    0x55,0x3f,0x2a,0x00,0xf0,0xfb,0xff,0x00,0xa4,0xa0,0xa0,0x00,0x80,0x80,0x80,0x00,0x00,0x00,0xff,0x00,
    0x00,0xff,0x00,0x00,0x00,0xff,0xff,0x00,0xff,0x00,0x00,0x00,0xff,0x00,0xff,0x00,0xff,0xff,0x00,0x00,
    0xff,0xff,0xff,0x00
};

const unsigned char palette256_web216[] = {
    0xff,0xff,0xff,0x00,0xcc,0xff,0xff,0x00,0x99,0xff,0xff,0x00,0x66,0xff,0xff,0x00,0x33,0xff,0xff,0x00,
    0x00,0xff,0xff,0x00,0xff,0xcc,0xff,0x00,0xcc,0xcc,0xff,0x00,0x99,0xcc,0xff,0x00,0x66,0xcc,0xff,0x00,
    0x33,0xcc,0xff,0x00,0x00,0xcc,0xff,0x00,0xff,0x99,0xff,0x00,0xcc,0x99,0xff,0x00,0x99,0x99,0xff,0x00,
    0x66,0x99,0xff,0x00,0x33,0x99,0xff,0x00,0x00,0x99,0xff,0x00,0xff,0x66,0xff,0x00,0xcc,0x66,0xff,0x00,
    0x99,0x66,0xff,0x00,0x66,0x66,0xff,0x00,0x33,0x66,0xff,0x00,0x00,0x66,0xff,0x00,0xff,0x33,0xff,0x00,
    0xcc,0x33,0xff,0x00,0x99,0x33,0xff,0x00,0x66,0x33,0xff,0x00,0x33,0x33,0xff,0x00,0x00,0x33,0xff,0x00,
    0xff,0x00,0xff,0x00,0xcc,0x00,0xff,0x00,0x99,0x00,0xff,0x00,0x66,0x00,0xff,0x00,0x33,0x00,0xff,0x00,
    0x00,0x00,0xff,0x00,0xff,0xff,0xcc,0x00,0xcc,0xff,0xcc,0x00,0x99,0xff,0xcc,0x00,0x66,0xff,0xcc,0x00,
    0x33,0xff,0xcc,0x00,0x00,0xff,0xcc,0x00,0xff,0xcc,0xcc,0x00,0xcc,0xcc,0xcc,0x00,0x99,0xcc,0xcc,0x00,
    0x66,0xcc,0xcc,0x00,0x33,0xcc,0xcc,0x00,0x00,0xcc,0xcc,0x00,0xff,0x99,0xcc,0x00,0xcc,0x99,0xcc,0x00,
    0x99,0x99,0xcc,0x00,0x66,0x99,0xcc,0x00,0x33,0x99,0xcc,0x00,0x00,0x99,0xcc,0x00,0xff,0x66,0xcc,0x00,
    0xcc,0x66,0xcc,0x00,0x99,0x66,0xcc,0x00,0x66,0x66,0xcc,0x00,0x33,0x66,0xcc,0x00,0x00,0x66,0xcc,0x00,
    0xff,0x33,0xcc,0x00,0xcc,0x33,0xcc,0x00,0x99,0x33,0xcc,0x00,0x66,0x33,0xcc,0x00,0x33,0x33,0xcc,0x00,
    0x00,0x33,0xcc,0x00,0xff,0x00,0xcc,0x00,0xcc,0x00,0xcc,0x00,0x99,0x00,0xcc,0x00,0x66,0x00,0xcc,0x00,
    0x33,0x00,0xcc,0x00,0x00,0x00,0xcc,0x00,0xff,0xff,0x99,0x00,0xcc,0xff,0x99,0x00,0x99,0xff,0x99,0x00,
    0x66,0xff,0x99,0x00,0x33,0xff,0x99,0x00,0x00,0xff,0x99,0x00,0xff,0xcc,0x99,0x00,0xcc,0xcc,0x99,0x00,
    0x99,0xcc,0x99,0x00,0x66,0xcc,0x99,0x00,0x33,0xcc,0x99,0x00,0x00,0xcc,0x99,0x00,0xff,0x99,0x99,0x00,
    0xcc,0x99,0x99,0x00,0x99,0x99,0x99,0x00,0x66,0x99,0x99,0x00,0x33,0x99,0x99,0x00,0x00,0x99,0x99,0x00,
    0xff,0x66,0x99,0x00,0xcc,0x66,0x99,0x00,0x99,0x66,0x99,0x00,0x66,0x66,0x99,0x00,0x33,0x66,0x99,0x00,
    0x00,0x66,0x99,0x00,0xff,0x33,0x99,0x00,0xcc,0x33,0x99,0x00,0x99,0x33,0x99,0x00,0x66,0x33,0x99,0x00,
    0x33,0x33,0x99,0x00,0x00,0x33,0x99,0x00,0xff,0x00,0x99,0x00,0xcc,0x00,0x99,0x00,0x99,0x00,0x99,0x00,
    0x66,0x00,0x99,0x00,0x33,0x00,0x99,0x00,0x00,0x00,0x99,0x00,0xff,0xff,0x66,0x00,0xcc,0xff,0x66,0x00,
    0x99,0xff,0x66,0x00,0x66,0xff,0x66,0x00,0x33,0xff,0x66,0x00,0x00,0xff,0x66,0x00,0xff,0xcc,0x66,0x00,
    0xcc,0xcc,0x66,0x00,0x99,0xcc,0x66,0x00,0x66,0xcc,0x66,0x00,0x33,0xcc,0x66,0x00,0x00,0xcc,0x66,0x00,
    0xff,0x99,0x66,0x00,0xcc,0x99,0x66,0x00,0x99,0x99,0x66,0x00,0x66,0x99,0x66,0x00,0x33,0x99,0x66,0x00,
    0x00,0x99,0x66,0x00,0xff,0x66,0x66,0x00,0xcc,0x66,0x66,0x00,0x99,0x66,0x66,0x00,0x66,0x66,0x66,0x00,
    0x33,0x66,0x66,0x00,0x00,0x66,0x66,0x00,0xff,0x33,0x66,0x00,0xcc,0x33,0x66,0x00,0x99,0x33,0x66,0x00,
    0x66,0x33,0x66,0x00,0x33,0x33,0x66,0x00,0x00,0x33,0x66,0x00,0xff,0x00,0x66,0x00,0xcc,0x00,0x66,0x00,
    0x99,0x00,0x66,0x00,0x66,0x00,0x66,0x00,0x33,0x00,0x66,0x00,0x00,0x00,0x66,0x00,0xff,0xff,0x33,0x00,
    0xcc,0xff,0x33,0x00,0x99,0xff,0x33,0x00,0x66,0xff,0x33,0x00,0x33,0xff,0x33,0x00,0x00,0xff,0x33,0x00,
    0xff,0xcc,0x33,0x00,0xcc,0xcc,0x33,0x00,0x99,0xcc,0x33,0x00,0x66,0xcc,0x33,0x00,0x33,0xcc,0x33,0x00,
    0x00,0xcc,0x33,0x00,0xff,0x99,0x33,0x00,0xcc,0x99,0x33,0x00,0x99,0x99,0x33,0x00,0x66,0x99,0x33,0x00,
    0x33,0x99,0x33,0x00,0x00,0x99,0x33,0x00,0xff,0x66,0x33,0x00,0xcc,0x66,0x33,0x00,0x99,0x66,0x33,0x00,
    0x66,0x66,0x33,0x00,0x33,0x66,0x33,0x00,0x00,0x66,0x33,0x00,0xff,0x33,0x33,0x00,0xcc,0x33,0x33,0x00,
    0x99,0x33,0x33,0x00,0x66,0x33,0x33,0x00,0x33,0x33,0x33,0x00,0x00,0x33,0x33,0x00,0xff,0x00,0x33,0x00,
    0xcc,0x00,0x33,0x00,0x99,0x00,0x33,0x00,0x66,0x00,0x33,0x00,0x33,0x00,0x33,0x00,0x00,0x00,0x33,0x00,
    0xff,0xff,0x00,0x00,0xcc,0xff,0x00,0x00,0x99,0xff,0x00,0x00,0x66,0xff,0x00,0x00,0x33,0xff,0x00,0x00,
    0x00,0xff,0x00,0x00,0xff,0xcc,0x00,0x00,0xcc,0xcc,0x00,0x00,0x99,0xcc,0x00,0x00,0x66,0xcc,0x00,0x00,
    0x33,0xcc,0x00,0x00,0x00,0xcc,0x00,0x00,0xff,0x99,0x00,0x00,0xcc,0x99,0x00,0x00,0x99,0x99,0x00,0x00,
    0x66,0x99,0x00,0x00,0x33,0x99,0x00,0x00,0x00,0x99,0x00,0x00,0xff,0x66,0x00,0x00,0xcc,0x66,0x00,0x00,
    0x99,0x66,0x00,0x00,0x66,0x66,0x00,0x00,0x33,0x66,0x00,0x00,0x00,0x66,0x00,0x00,0xff,0x33,0x00,0x00,
    0xcc,0x33,0x00,0x00,0x99,0x33,0x00,0x00,0x66,0x33,0x00,0x00,0x33,0x33,0x00,0x00,0x00,0x33,0x00,0x00,
    0xff,0x00,0x00,0x00,0xcc,0x00,0x00,0x00,0x99,0x00,0x00,0x00,0x66,0x00,0x00,0x00,0x33,0x00,0x00,0x00,
    0x00,0x00,0x00,0x00,0x80,0x80,0x80,0x00,0xc0,0xc0,0xc0,0x00,0x80,0x00,0x00,0x00,0x80,0x80,0x00,0x00,
    0x00,0x80,0x00,0x00,0x00,0x80,0x80,0x00,0x80,0x00,0x80,0x00,0x00,0x00,0x80,0x00,0xff,0xff,0xff,0x00,
    0xf6,0xf6,0xf6,0x00,0xee,0xee,0xee,0x00,0xe6,0xe6,0xe6,0x00,0xde,0xde,0xde,0x00,0xd5,0xd5,0xd5,0x00,
    0xcd,0xcd,0xcd,0x00,0xc5,0xc5,0xc5,0x00,0xbd,0xbd,0xbd,0x00,0xb4,0xb4,0xb4,0x00,0xac,0xac,0xac,0x00,
    0xa4,0xa4,0xa4,0x00,0x9c,0x9c,0x9c,0x00,0x94,0x94,0x94,0x00,0x8b,0x8b,0x8b,0x00,0x83,0x83,0x83,0x00,
    0x7b,0x7b,0x7b,0x00,0x73,0x73,0x73,0x00,0x6a,0x6a,0x6a,0x00,0x62,0x62,0x62,0x00,0x5a,0x5a,0x5a,0x00,
    0x52,0x52,0x52,0x00,0x4a,0x4a,0x4a,0x00,0x41,0x41,0x41,0x00,0x39,0x39,0x39,0x00,0x31,0x31,0x31,0x00,
    0x29,0x29,0x29,0x00,0x20,0x20,0x20,0x00,0x18,0x18,0x18,0x00,0x10,0x10,0x10,0x00,0x08,0x08,0x08,0x00,
    0x00,0x00,0x00,0x00
};

